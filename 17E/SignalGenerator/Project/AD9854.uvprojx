# Keil uVision project AD9854.uvprojx, settings and files
target STM32_CharLCD (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: AD9854 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\User;..\CMSIS;..\CMSIS\CoreSupport;..\CMSIS\DeviceSupport\STM32F10x;..\STM32F10x_StdPeriph_Driver\inc;..\User\Delay;..\User\CharLCD;..\User\PeripheralInit;..\SYSTEM;..\BSP\RDA5820;..\BSP\DMA;..\BSP\ADC;..\SYSTME\sys;..\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ../User/: main.c CharLCD.c Delay.c AD9854.c
    ../BSP/ADC/: adc.c
    ../BSP/DMA/: dma.c
    ../BSP/RDA5820/: myiic.c
    ../BSP/LED/: led.c
    ../BSP/PE4302/: pe4302.c
    ../BSP/KEY/: key.c
  group StdPeriph_Driver
    ../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c
  group CMSIS
    ../CMSIS/CoreSupport/: core_cm3.c
    ../CMSIS/DeviceSupport/STM32F10x/: system_stm32f10x.c
  group Startup
    ../CMSIS/DeviceSupport/STM32F10x/: startup_stm32f10x_hd.s
  group SYS
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
software components: Device:StdPeriph Drivers:DAC 3.6.0
